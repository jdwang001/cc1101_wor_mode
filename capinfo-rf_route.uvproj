# Keil uVision project capinfo-rf_route.uvproj, settings and files
target rf_route (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: capinfo-rf_route +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceCode
    ./: mcu_config.c rf_config.c main.c rf_route.c
